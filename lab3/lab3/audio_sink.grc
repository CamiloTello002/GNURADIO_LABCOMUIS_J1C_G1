options:
  parameters:
    generate_options: qt_gui
    id: audio_sink
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: angelica_galindo
  id: variable
  parameters:
    comment: |-
      Este va a ser un comentario de prueba.
      Este pedazo de comentario es el que queremos ver en alguno de los 
      dos archivos para ver si podemos avanzar con el laboratorio.
    value: '4000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 22.05e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: 22.05e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2200'
    offset: '0'
    phase: '0'
    samp_rate: 22.05e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
